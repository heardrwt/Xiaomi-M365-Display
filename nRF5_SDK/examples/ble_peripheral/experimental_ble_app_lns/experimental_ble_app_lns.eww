<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\s132\iar\experimental_ble_app_lns_pca10056_s132.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10028\s130\iar\experimental_ble_app_lns_pca10028_s130.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\s132\iar\experimental_ble_app_lns_pca10040_s132.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s132_spi\iar\experimental_ble_app_lns_pca10040_s132_spi.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s132_hci\iar\experimental_ble_app_lns_pca10040_s132_hci.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s132_uart\iar\experimental_ble_app_lns_pca10040_s132_uart.ewp</path>
  </project>  <batchBuild/>
</workspace>