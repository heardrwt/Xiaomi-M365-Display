<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10028\blank\iar\direct_test_mode_pca10028.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\blank\iar\direct_test_mode_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10028\s130\iar\direct_test_mode_pca10028_s130.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\s132\iar\direct_test_mode_pca10040_s132.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\s332\iar\direct_test_mode_pca10040_s332_po.ewp</path>
  </project>  <batchBuild/>
</workspace>