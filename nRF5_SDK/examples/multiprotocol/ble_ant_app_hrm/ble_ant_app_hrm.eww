<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040\s332\iar\ble_ant_app_hrm_pca10040_s332.ewp</path>
  </project>  <batchBuild/>
</workspace>